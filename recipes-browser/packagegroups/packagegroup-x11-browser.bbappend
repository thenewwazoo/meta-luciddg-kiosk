
RDEPENDS_${PN} = "\
    matchbox-keyboard   \
    matchbox-keyboard-im    \
    liberation-fonts \
    chromium-imx  \
    "
